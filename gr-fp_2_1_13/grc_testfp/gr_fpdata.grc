<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0</value></param>
<param><key>note</key><value>Data path</value></param>
</block>
<block>
<key>gr_udp_source</key>
<param><key>id</key><value>gr_udp_source_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ipaddr</key><value>192.168.2.200</value></param>
<param><key>port</key><value>9997</value></param>
<param><key>psize</key><value>18*50</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>wait</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0_1</value></param>
<param><key>file</key><value>test_raw.bin</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>fpgnu_fpdata_sink</key>
<param><key>id</key><value>fpgnu_fpdata_sink_0</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0_1_0</value></param>
<param><key>file</key><value>test_fp_out.bin</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<connection><source_block_id>gr_udp_source_0</source_block_id><sink_block_id>gr_file_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_udp_source_0</source_block_id><sink_block_id>fpgnu_fpdata_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fpgnu_fpdata_sink_0</source_block_id><sink_block_id>gr_file_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
