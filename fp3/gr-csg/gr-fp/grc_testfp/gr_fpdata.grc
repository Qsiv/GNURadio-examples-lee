<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0</value></param>
<param><key>note</key><value>Data path</value></param>
</block>
<block>
<key>gr_udp_source</key>
<param><key>id</key><value>gr_udp_source_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>ipaddr</key><value>192.168.2.200</value></param>
<param><key>port</key><value>9997</value></param>
<param><key>psize</key><value>590</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>wait</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0_1</value></param>
<param><key>file</key><value>/home/cgardner/sandbox/gr-csg/gr-fp/grc_testfp/test_raw_even.bin</value></param>
<param><key>type</key><value>short</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0_1_0</value></param>
<param><key>file</key><value>/home/cgardner/sandbox/gr-csg/gr-fp/grc_testfp/test_fp_odd.bin</value></param>
<param><key>type</key><value>short</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>gr_short_to_float</key>
<param><key>id</key><value>gr_short_to_float_0_0</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gr_short_to_float</key>
<param><key>id</key><value>gr_short_to_float_0</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>gr_deinterleave</key>
<param><key>id</key><value>gr_deinterleave_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>num_streams</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>fpgnu_fpdata_sink</key>
<param><key>id</key><value>fpgnu_fpdata_sink_0</value></param>
<param><key>rm_head</key><value>remove_head</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>remove_head</value></param>
<param><key>label</key><value>Remove Head</value></param>
<param><key>value</key><value>0</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<connection><source_block_id>gr_udp_source_0</source_block_id><sink_block_id>fpgnu_fpdata_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_short_to_float_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_deinterleave_0</source_block_id><sink_block_id>gr_file_sink_0_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fpgnu_fpdata_sink_0</source_block_id><sink_block_id>gr_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_deinterleave_0</source_block_id><sink_block_id>gr_file_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_short_to_float_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_deinterleave_0</source_block_id><sink_block_id>gr_short_to_float_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_deinterleave_0</source_block_id><sink_block_id>gr_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
